## boards/shields/pedals/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config SHIELD_PEDALS
    def_bool $(shields_list_contains,pedals)
```
